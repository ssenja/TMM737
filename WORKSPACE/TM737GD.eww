<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PROJ\TMM384G\TMM384G.ewp</path>
  </project>
  <batchBuild/>
</workspace>


