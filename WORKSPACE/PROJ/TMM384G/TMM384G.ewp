# IAR project TMM384G.ewp, settings and files
configuration GD32H7xx (ARM, debug)
  General.OGChipSelectEditMenu: GD32H737xI GD GD32H737xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H73X_75X
  ICCARM.CCIncludePath2: INC; ..\..\..\BSP\GD32H7xx_HAL\INC; ..\..\..\BSP\CMSIS\GD\GD32H73x_75x\INC; ..\..\..\BSP\BOARD\INC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: TMM384G.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32H737xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    SRC/: main.c sdram.c
  group BSP/BOARD
    ../../../BSP/BOARD/SRC/: gd32h73x_75x_it.c systick.c
  group BSP/CMSIS
    ../../../BSP/CMSIS/GD/GD32H73x_75x/SRC/IAR/: startup_gd32h73x_75x.s
    ../../../BSP/CMSIS/GD/GD32H73x_75x/SRC/: system_gd32h73x_75x.c
  group BSP/GD32H7xx_HAL
    ../../../BSP/GD32H7xx_HAL/SRC/: gd32h73x_75x_adc.c gd32h73x_75x_can.c gd32h73x_75x_cau.c gd32h73x_75x_cau_aes.c gd32h73x_75x_cau_des.c gd32h73x_75x_cau_tdes.c gd32h73x_75x_cmp.c gd32h73x_75x_cpdm.c gd32h73x_75x_crc.c gd32h73x_75x_ctc.c gd32h73x_75x_dac.c gd32h73x_75x_dbg.c gd32h73x_75x_dci.c gd32h73x_75x_dma.c gd32h73x_75x_edout.c gd32h73x_75x_efuse.c gd32h73x_75x_enet.c gd32h73x_75x_exmc.c gd32h73x_75x_exti.c gd32h73x_75x_fac.c gd32h73x_75x_fmc.c gd32h73x_75x_fwdgt.c gd32h73x_75x_gpio.c gd32h73x_75x_hau.c gd32h73x_75x_hau_sha_md5.c gd32h73x_75x_hpdf.c gd32h73x_75x_hwsem.c gd32h73x_75x_i2c.c gd32h73x_75x_ipa.c gd32h73x_75x_lpdts.c gd32h73x_75x_mdio.c gd32h73x_75x_mdma.c gd32h73x_75x_misc.c gd32h73x_75x_ospi.c gd32h73x_75x_ospim.c gd32h73x_75x_pmu.c gd32h73x_75x_rameccmu.c gd32h73x_75x_rcu.c gd32h73x_75x_rspdif.c gd32h73x_75x_rtc.c gd32h73x_75x_rtdec.c gd32h73x_75x_sai.c gd32h73x_75x_sdio.c gd32h73x_75x_spi.c gd32h73x_75x_syscfg.c gd32h73x_75x_timer.c gd32h73x_75x_tli.c gd32h73x_75x_tmu.c gd32h73x_75x_trigsel.c gd32h73x_75x_trng.c gd32h73x_75x_usart.c gd32h73x_75x_vref.c gd32h73x_75x_wwdgt.c
